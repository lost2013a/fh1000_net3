# Keil uVision project Project.uvprojx, settings and files
target STM32427_ETH (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FH1000_NET3_NTP +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427X,USE_STM324x7I_EVAL
  c include: ..\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM324x7I_EVAL;..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\Utilities\Third_Party\lwip-1.4.1;..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\Standalone;..\..\Utilities\Third_Party\ptpd-2.3.1-rc3\src;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Bsp
    ./: startup_stm32f427x.s
    ../src/: system_stm32f4xx.c stm32f4xx_it.c stm32f4x7_eth_bsp.c ethernetif.c serial_hand.c flash_hand.c can.c
  group User
    ../src/: main.c netconf.c share.c ntp.c lcdmessage.c arm2fpga.c pc2cfg.c
  group STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Ptpd
    ../../Utilities/Third_Party/ptpd-2.3.1-rc3/src/: ptpd.c protocol.c bmc.c arith.c display.c management.c
    ../../Utilities/Third_Party/ptpd-2.3.1-rc3/src/dep/: timer.c servo.c net.c msg.c stmptp_sys_time.c startup.c
  group Lwip
    ../../Utilities/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
  group 修改和说明
    ./: 注释说明.txt 修改记录.txt
